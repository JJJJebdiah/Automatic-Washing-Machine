# Keil uVision project AWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: AWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c AWM.c AWM.h digital_tube.c digital_tube.h key.c key.h lcd1602.c lcd1602.h public.c public.h serial.c serial.h stepper.c stepper.h buzzer.c buzzer.h ired.c ired.h
